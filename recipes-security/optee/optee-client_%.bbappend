do_install:append:tda54-vdk() {
    rm -rf ${D}/usr/lib/systemd
}
