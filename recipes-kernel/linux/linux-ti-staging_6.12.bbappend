require rtos-mem-map.inc

SRCREV = "c532e0273c7dfb1e3e135334bcad765350503538"

KERNEL_GIT_PROTOCOL = "ssh"

KERNEL_GIT_URI = "git://git@bitbucket.itg.ti.com/~a0501904/ti-linux-kernel.git"
