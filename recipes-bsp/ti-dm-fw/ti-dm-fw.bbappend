TI_LINUX_FW_GIT_URI = "git://git@bitbucket.itg.ti.com/~a0501904/ti-linux-firmware.git"

TI_LINUX_FW_GIT_PROTOCOL = "ssh"

DM_FIRMWARE:am62axx = "dm_adas_mcu1_0_release_strip.out"

SRCREV = "ebb0e9f6cb0244dcf1c1ecfd79173f3073e5f420"

PR:append = "_edgeai_0"
