TI_LINUX_FW_GIT_URI = "git://git@bitbucket.itg.ti.com/~a0501904/ti-linux-firmware.git"

TI_LINUX_FW_GIT_PROTOCOL = "ssh"

SRCREV = "c5d89b9ec344a422d7d7b3fa33badf75a14eede6"

PR:append = "_edgeai_0"
