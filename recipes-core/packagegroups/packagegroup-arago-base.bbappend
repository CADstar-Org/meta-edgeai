RDEPENDS:${PN}:remove:tda54-vdk = "systemd-telnetd dbus-broker arago-gpl-notice"
