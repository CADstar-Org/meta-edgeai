RDEPENDS:${PN}:remove:tda54-vdk = "bt-enable"
